# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\User;.\Libraries\CMSIS;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Public;.\FreeRTOS\inc;.\FreeRTOS\prot;.\FreeRTOS\src;.\FreeRTOS;.\APP\led;.\APP\usart;.\APP\key;.\APP\pwm;.\APP\ec11;.\APP\dc_motor;.\APP\usart;.\APP\task;.\APP\screen;.\APP\Infrared;.\APP\sr04;.\APP\liquid_level;.\APP\my_queue;.\APP\my_event;.\APP\config;.\APP\ADC;.\Libraries\STM32F10x_StdPeriph_Driver\src;.\APP\sg90
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./User/: main.c stm32f10x_it.c
  group Startup
    ./Libraries/CMSIS/: startup_stm32f10x_md.s
  group FreeRTOS/src
    ./FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ./FreeRTOS/prot/: heap_4.c port.c
  group FreeRTOS/inc
    ./FreeRTOS/: FreeRTOSConfig.h
    ./FreeRTOS/inc/: event_groups.h FreeRTOS.h list.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_dma.c
  group CMSIS
    ./Libraries/CMSIS/: system_stm32f10x.c core_cm3.c
  group APP
    ./APP/led/: led.c
    ./APP/usart/: usart.c usart3.c
    ./APP/key/: key.c
    ./APP/dc_motor/: dc_motor.c
    ./APP/screen/: screen.c
    ./APP/task/: my_task.c
    ./APP/Infrared/: Infrared.c
    ./APP/sr04/: sr04.c
    ./APP/liquid_level/: liquid_level.c
    ./APP/my_queue/: my_queue.c
    ./APP/my_event/: my_event.c
    ./APP/config/: config.c
    ./APP/ADC/: adc.c
    ./APP/sg90/: sg90.c
  group Public
    ./Public/: system.c SysTick.c
